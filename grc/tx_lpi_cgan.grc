options:
  parameters:
    author: yasht
    description: LPI-CGAN Covert Transmitter (clean path - no RRC, no scrambler)
    generate_options: qt_gui
    id: tx_lpi_cgan
    output_language: python
    title: LPI-CGAN Transmitter
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: 1 MS/s covert streaming
    value: '1000000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: 750 MHz RF Carrier
    value: '750000000'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '25'
  states: {}
- name: frame_size
  id: variable
  parameters:
    value: '512'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: Ground-truth message (bits repeat)
    file: C:\\Users\\gspra\\OneDrive\\Desktop\\LPI_CGAN\\test_message.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_file_sink_bits
  id: blocks_file_sink
  parameters:
    comment: Ground-truth bit stream (MSB-first unpacked bytes) for offline BER
    file: C:\\Users\\gspra\\OneDrive\\Desktop\\LPI_CGAN\\tx_bits.uint8
    type: byte
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: byte 0 -> -1, byte 1 -> +1 (matches decoder sigmoid target)
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: (-1,1)
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    comment: Accumulate 256 BPSK symbols into one message vector
    num_items: '256'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import os, numpy as np
      from gnuradio import gr

      class cgan_generator_block(gr.sync_block):
          def __init__(self, model_path='generator_lpi.pt', gain_factor=0.35):
              gr.sync_block.__init__(self, name='CGAN_LPI_Generator', in_sig=[(np.complex64, 256)], out_sig=[(np.complex64, 512)])
              import torch
              self.torch = torch
              self.device = 'cpu'
              if not os.path.exists(model_path):
                  for cand in ['generator_lpi.pt', 'C:/Users/gspra/OneDrive/Desktop/LPI_CGAN/generator_lpi.pt', '../generator_lpi.pt']:
                      if os.path.exists(cand):
                          model_path = cand
                          break
              self.model = torch.jit.load(model_path, map_location=self.device)
              self.model.eval()
              self.gain = gain_factor
              self.gpu_noise = torch.zeros(1, 64, dtype=torch.float32, device=self.device)
              self.b_tensor = torch.zeros(1, 256, dtype=torch.float32, device=self.device)
              print(f'[CGAN Gen] Loaded from {model_path} on {self.device}')

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              for i in range(len(in0)):
                  frame = in0[i]
                  self.b_tensor[0, :] = self.torch.from_numpy(frame.real.astype(np.float32))
                  self.gpu_noise.normal_(mean=0, std=1)
                  with self.torch.no_grad():
                      covert = self.model(self.gpu_noise, self.b_tensor)
                  c_np = covert.cpu().numpy()[0]
                  out[i] = (c_np[0, :] + 1j * c_np[1, :]).astype(np.complex64) * self.gain
              return len(in0)
    comment: CGAN Covert Generator
    gain_factor: '0.35'
    model_path: '''generator_lpi.pt'''
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '512'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: center_freq
    gain0: tx_gain
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Covert I
    label2: Covert Q
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_file_sink_bits, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', epy_block_0, '0']
- [epy_block_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_vector_to_stream_0, '0', uhd_usrp_sink_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
