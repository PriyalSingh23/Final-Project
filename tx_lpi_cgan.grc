options:
  parameters:
    author: yasht
    description: CGAN TX lab scaffold; baseband disabled by default; no OTA validation
    generate_options: qt_gui
    id: tx_lpi_cgan
    output_language: python
    title: LPI-CGAN Transmitter
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: Placeholder only; select a rate supported by your exact USRP before running
    value: '32000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: 'UNSET: enter an authorized frequency supported by your exact USRP before running'
    value: '0'
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: frame_size
  id: variable
  parameters:
    value: '512'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: Ground-truth message (bits repeat)
    file: test_message.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_file_sink_bits
  id: blocks_file_sink
  parameters:
    comment: Ground-truth bit stream (MSB-first unpacked bytes) for offline BER
    file: tx_bits.uint8
    type: byte
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: byte 0 -> -1, byte 1 -> +1 (matches decoder sigmoid target)
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: (-1,1)
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    comment: Accumulate 256 BPSK symbols into one message vector
    num_items: '256'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source: |
      import numpy as np
      from gnuradio import gr

      class cgan_generator_block(gr.sync_block):
          def __init__(self, model_path='generator_lpi.pt', gain_factor=0.35, tx_enable=False):
              gr.sync_block.__init__(self, name='CGAN_LPI_Generator', in_sig=[(np.complex64, 256)], out_sig=[(np.complex64, 512)])
              import torch
              self.torch = torch
              self.device = 'cuda' if torch.cuda.is_available() else 'cpu'
              self.model = torch.jit.load(model_path, map_location=self.device).eval()
              self.gain = float(gain_factor)
              self.tx_enable = bool(tx_enable)
              print(f'[CGAN Gen] Loaded on {self.device}; tx_enable={self.tx_enable}')
              if not self.tx_enable:
                  print('[CGAN Gen] Baseband output is zero while disabled. This is NOT a hardware RF interlock.')

          def work(self, input_items, output_items):
              frames = input_items[0]
              out = output_items[0]
              if not self.tx_enable:
                  out[:] = 0
                  return len(frames)
              if len(frames) == 0:
                  return 0
              bits_np = np.ascontiguousarray(frames.real, dtype=np.float32)
              bits = self.torch.from_numpy(bits_np).to(self.device)
              noise = self.torch.randn(len(frames), 64, device=self.device)
              with self.torch.inference_mode():
                  waveform = self.model(noise, bits)
              iq = waveform[:, 0, :].cpu().numpy() + 1j * waveform[:, 1, :].cpu().numpy()
              out[:] = (self.gain * iq).astype(np.complex64, copy=False)
              return len(frames)
    comment: Baseband generator; disabled by default; not an RF interlock
    gain_factor: '0.35'
    tx_enable: 'False'
    model_path: generator_lpi.pt
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '512'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: center_freq
    gain0: tx_gain
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Covert I
    label2: Covert Q
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_file_sink_bits, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', epy_block_0, '0']
- [epy_block_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_vector_to_stream_0, '0', uhd_usrp_sink_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
