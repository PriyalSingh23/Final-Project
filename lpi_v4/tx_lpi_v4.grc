options:
  parameters:
    author: PriyalSingh23 / ShadowComm
    description: Message -> AES/RS -> keyed spread frames -> CGAN waveform -> USRP. Needs the lpi_v4 folder (lpi_grc.py, lpi_core.py, exported .pt).
    generate_options: qt_gui
    id: tx_lpi_v4
    output_language: python
    title: ShadowComm LPI v4 Transmitter
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: B210 minimum is ~208.3 kS/s; 245760 = 61.44 MHz/250 (exact integer)
    value: '245760'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: same on TX and RX; the LPI gain is in the waveform, not in a low carrier
    value: 2.484e9
  states: {}
- name: tx_gain
  id: variable
  parameters:
    comment: start at 0 dB and raise only until the RX locks
    value: '0'
  states: {}
- name: lpi_dir
  id: variable
  parameters:
    comment: folder containing lpi_core.py / lpi_grc.py / the exported weights
    value: '"/home/user/Final-Project/lpi_v4"'
  states: {}
- name: tx_bits_file
  id: variable
  parameters:
    comment: raw uint8 file; each byte becomes 8 payload bits (see make_bits_file.py)
    value: '"/tmp/lpi_bits.dat"'
  states: {}
- name: ckpt
  id: variable
  parameters:
    value: '"/home/user/Final-Project/lpi_v4/run/lpi_v4.best.pt"'
  states: {}
- name: cfg_json
  id: variable
  parameters:
    value: '"/home/user/Final-Project/lpi_v4/run/lpi_v4.best.json"'
  states: {}
- name: session_key
  id: variable
  parameters:
    comment: must equal the RX key
    value: '"SESSION-KEY"'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: packed bytes -> 8 bits each
    file: ${tx_bits_file}
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_chunks_to_symbols_bc_0
  id: digital_chunks_to_symbols_bc
  parameters:
    comment: 0 -> +1, 1 -> -1 (the block thresholds the real part, so either mapping decodes)
    constellation: '[-1, 1]'
    dim: '1'
    label: ''
    num_rows: '1'
    num_ports: '1'
    precision: '32'
    symbol_table: ''
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    comment: one frame = 128 symbols
    num_items: '128'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source: |
      import numpy as np
      from gnuradio import gr
      import os, sys
      LPI_DIR = os.path.expanduser(lpi_dir)
      if LPI_DIR not in sys.path:
          sys.path.insert(0, LPI_DIR)
      import lpi_grc as _g


      class lpi_tx(gr.sync_block):
          """BPSK symbol vector (n_bits) -> LPI IQ frame (pilot + spread payload)."""

          def __init__(self, lpi_dir="", ckpt="", cfg_json="", key="SESSION-KEY", amp=0.05):
              core = _g.TxCore(ckpt, cfg_json, key, amp)
              gr.sync_block.__init__(self, name="lpi_tx",
                                     in_sig=[(np.complex64, core.in_len())],
                                     out_sig=[(np.complex64, core.out_len())])
              self.core = core

          def work(self, input_items, output_items):
              return self.core.work(input_items[0], output_items[0])
    comment: LPI v4 keyed spread + pilot framing
    amp: '0.05'
    ckpt: ${ckpt}
    cfg_json: ${cfg_json}
    key: ${session_key}
    lpi_dir: ${lpi_dir}
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    comment: 576 samples/frame = 64 pilot + 512 payload
    num_items: '576'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: ${center_freq}
    gain0: ${tx_gain}
    samp_rate: ${samp_rate}
    sync: none
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    axislabels: '[''Time (s)'', ''Amplitude'']'
    comment: the waveform should *look* like noise on the scope
    grid: 'True'
    label1: LPI IQ (I)
    label2: LPI IQ (Q)
    name: LPI v4 TX
    npoints: '2048'
    srate: ${samp_rate}
    tr_mode: tr_auto
    tr_out_skipped: 'False'
    tr_tags: 'False'
    type: complex
    width: '800'
    yaxislabel: Amplitude
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_chunks_to_symbols_bc_0, '0']
- [digital_chunks_to_symbols_bc_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', epy_block_0, '0']
- [epy_block_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_vector_to_stream_0, '0', uhd_usrp_sink_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
