options:
  parameters:
    author: PriyalSingh23 / ShadowComm
    description: USRP IQ -> keyed-pilot sync (timing/CFO/phase) -> MF+ZF decode -> RS(42,34) + CRC-8 + AES -> text.  Prints to the console GRC runs in.
    generate_options: qt_gui
    id: rx_lpi_v4
    output_language: python
    title: ShadowComm LPI v4 Receiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: MUST equal the TX rate (lpi_config.json)
    value: '245760'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: same as TX
    value: 2.484e9
  states: {}
- name: rx_gain
  id: variable
  parameters:
    comment: start ~30 dB; the LPI signal is *below* the noise floor
    value: '30'
  states: {}
- name: lpi_dir
  id: variable
  parameters:
    value: '"/home/user/Final-Project/lpi_v4"'
  states: {}
- name: ckpt
  id: variable
  parameters:
    value: '"/home/user/Final-Project/lpi_v4/run/lpi_v4.best.pt"'
  states: {}
- name: cfg_json
  id: variable
  parameters:
    value: '"/home/user/Final-Project/lpi_v4/run/lpi_v4.best.json"'
  states: {}
- name: session_key
  id: variable
  parameters:
    value: '"SESSION-KEY"'
  states: {}
- name: capture_file
  id: variable
  parameters:
    comment: fill in a .cs16/.fc32 file to replay a recording instead of the radio
    value: '""'
  states: {}
- name: out_file
  id: variable
  parameters:
    comment: one line per decoded burst
    value: '"lpi_rx.log"'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: OPTIONAL replay input -- leave the path empty and use the UHD source (double-click this block and set file= to replay)
    file: '""'
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: 2e5
    dc_offs_0: '[0]'
    dc_offset_mode0: '0'
    gain0: ${rx_gain}
    gain_mode0: Manual
    iq_imbal_0: '[0]'
    iq_balance_mode0: '0'
    radio0: '["addr=\"\""]'
    rx_freq0: ${center_freq}
    rate0: ${samp_rate}
    rx_agc0: Disabled
    samp_rate: ${samp_rate}
    trigger_rate: 1e3
    tune_mame0: Manual
    type: fc32
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source: |
      import numpy as np
      from gnuradio import gr
      import os, sys
      LPI_DIR = os.path.expanduser(lpi_dir)
      if LPI_DIR not in sys.path:
          sys.path.insert(0, LPI_DIR)
      import lpi_grc as _g


      class lpi_rx(gr.sync_block):
          """IQ stream -> keyed pilot sync -> RS/AES -> text (printed + file)."""

          def __init__(self, lpi_dir="", ckpt="", cfg_json="", key="SESSION-KEY",
                       mode="ctr", out_file="", verbose=True, window=0):
              core = _g.RxCore(ckpt, cfg_json, key, mode, window, "cpu", verbose, out_file)
              gr.sync_block.__init__(self, name="lpi_rx", in_sig=[np.complex64], out_sig=[])
              self.core = core
              self.set_relative_rate(1.0)

          def work(self, input_items, output_items):
              return self.core.work(input_items[0])
    comment: sync + decode + CRC text (prints to stdout)
    ckpt: ${ckpt}
    cfg_json: ${cfg_json}
    key: ${session_key}
    lpi_dir: ${lpi_dir}
    mode: '"ctr"'
    out_file: ${out_file}
    verbose: 'True'
    window: '0'
  states: {}

connections:
- [uhd_usrp_source_0, '0', epy_block_0, '0']

metadata:
  file_format: 1
