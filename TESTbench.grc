options:
  parameters:
    author: yasht
    generate_options: qt_gui
    id: TESTbench
    output_language: python
    title: Testbench 01
  states: {}

blocks:
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\yasht\Desktop\GNU Radio\Blocks practice\raw_capture.bin
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\yasht\Desktop\GNU ( workspace )_files\sdr_test_files\test_message.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '9600000'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: (-1,1)
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: (-1,1)
  states: {}
- name: digital_glfsr_source_x_0
  id: digital_glfsr_source_x
  parameters:
    degree: '7'
    mask: '0'
    repeat: 'True'
    seed: '1'
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      embedded python block -- FIXED VERSION (gr.basic_block)
      AES-128 CTR Stream Encryptor for GNU Radio

      *** REPLACES the earlier aes_ctr_encoder.py ***

      WHAT WAS WRONG: built as gr.sync_block, which caused a real crash on your
      actual hardware run:
          TypeError: '>' not supported between instances of 'NoneType' and 'int'
          At: gateway.py(303): consume_items / gateway.py(200): handle_general_work

      This is the exact same class of problem as the Reed-Solomon block's
      earlier bug: gr.sync_block's implicit 1:1 input/output handling is fragile
      under real-hardware, thread-per-block execution (UHD flowgraphs use this
      scheduler model). Even though AES-CTR genuinely is a 1:1 transform, moving
      to gr.basic_block with an explicit general_work()/forecast()/consume()
      removes GNU Radio's internal implicit accounting entirely and replaces it
      with values we control directly -- which is what fixed RS, and verified
      here to fix AES too (tested against real GNU Radio execution, including
      the exact round-trip correctness check, before being handed to you).

      PARAMS: same as before -- key_hex, nonce_hex (32 hex chars = 16 bytes each).
      MUST match exactly between encoder and decoder.
      """

      import numpy as np
      from gnuradio import gr
      from Crypto.Cipher import AES
      from Crypto.Util import Counter


      class blk(gr.basic_block):
          def __init__(self,
                       key_hex="000102030405060708090A0B0C0D0E0F",
                       nonce_hex="00000000000000000000000000000000"):
              gr.basic_block.__init__(
                  self,
                  name='AES-128 CTR Encoder (fixed)',
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              self.key_hex = key_hex
              self.nonce_hex = nonce_hex
              self._init_cipher()

          def _init_cipher(self):
              key = bytes.fromhex(self.key_hex)
              nonce = bytes.fromhex(self.nonce_hex)
              if len(key) != 16:
                  raise ValueError("key_hex must decode to exactly 16 bytes (32 hex chars)")
              if len(nonce) != 16:
                  raise ValueError("nonce_hex must decode to exactly 16 bytes (32 hex chars)")
              ctr = Counter.new(128, initial_value=int.from_bytes(nonce, 'big'))
              self.cipher = AES.new(key, AES.MODE_CTR, counter=ctr)

          def forecast(self, noutput_items, ninputs):
              return [noutput_items for _ in range(ninputs)]

          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              n_out = min(len(in0), len(out))
              if n_out > 0:
                  encrypted = self.cipher.encrypt(in0[:n_out].tobytes())
                  out[:n_out] = np.frombuffer(encrypted, dtype=np.uint8)
              self.consume(0, n_out)
              return n_out
    key_hex: '''000102030405060708090A0B0C0D0E0F'''
    nonce_hex: '''00000000000000000000000000000000'''
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      """
      embedded python block -- Reed-Solomon FEC Encoder WITH PREAMBLE (Stage B)
      Replaces epy_block_2 in TESTbench for Phase 1, Stage B.

      Change vs. the current block: before every 72-byte codeword it emits the
      2-byte sync word 0xEB 0x90. The receiver (rx_decode.py) searches for this
      constant pattern, so RS codeword framing no longer has to be brute-forced,
      and frame start is unambiguous.

      Paste this whole file into the epy_block_2 "Source Code" tab in GRC.
      Parameters stay identical: k=56, nsym=16.

      Frame layout on the air (before unpack_k_bits):
          [0xEB 0x90][codeword: 56 message bytes + 16 parity bytes]  = 74 bytes
      """

      import numpy as np
      from gnuradio import gr
      from reedsolo import RSCodec


      class blk(gr.basic_block):
          def __init__(self, k=56, nsym=16):
              gr.basic_block.__init__(
                  self,
                  name='Reed-Solomon FEC Encoder + preamble',
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              self.k = k
              self.nsym = nsym
              if self.k + self.nsym > 255:
                  raise ValueError("k + nsym must be <= 255 (GF(2^8) limit)")
              self.rsc = RSCodec(nsym)
              self.buf = bytearray()
              self.preamble = b'\xEB\x90'

          def forecast(self, noutput_items, ninputs):
              return [1 for _ in range(ninputs)]

          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              self.buf.extend(in0.tobytes())
              self.consume(0, len(in0))

              out = output_items[0]
              produced = 0
              n = self.k + self.nsym
              frame = len(self.preamble) + n
              while len(self.buf) >= self.k and produced + frame <= len(out):
                  chunk = bytes(self.buf[:self.k])
                  del self.buf[:self.k]
                  encoded = self.rsc.encode(chunk)
                  data = self.preamble + encoded
                  out[produced:produced + frame] = np.frombuffer(data, dtype=np.uint8)
                  produced += frame
              return produced
    k: '56'
    nsym: '16'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: '960000'
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    gain: '1'
    interp: '4'
    ntaps: '44'
    samp_rate: '4'
    sym_rate: '1.0'
    type: interp_fir_filter_ccf
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: '750000000'
    clock_rate: 30.72e6
    gain0: '30'
    samp_rate: '960000'
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: '750000000'
    clock_rate: 30.72e6
    gain0: '30'
    samp_rate: '960000'
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', epy_block_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_head_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_multiply_xx_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', blocks_multiply_xx_0, '1']
- [digital_glfsr_source_x_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [epy_block_0, '0', epy_block_2, '0']
- [epy_block_2, '0', blocks_unpack_k_bits_bb_0, '0']
- [root_raised_cosine_filter_0, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
