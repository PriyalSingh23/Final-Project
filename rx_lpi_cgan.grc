options:
  parameters:
    author: yasht
    description: LPI-CGAN Receiver (raw capture + inline normalized decode) + USRP
    generate_options: qt_gui
    id: rx_lpi_cgan
    output_language: python
    title: LPI-CGAN Receiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '750000'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '30'
  states: {}
- name: frame_size
  id: variable
  parameters:
    value: '512'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    clock_rate: 30.72e6
    gain0: rx_gain
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: blocks_file_sink_raw
  id: blocks_file_sink
  parameters:
    comment: RAW baseband capture - feed ota_verify.py for offline alignment + BER + KS field test
    file: C:\\Users\\yasht\\Desktop\\LPI_CGAN\\rx_raw.fc32
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    comment: Accumulate 512 covert samples into one vector
    num_items: '512'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source: |
      import numpy as np
      from gnuradio import gr

      class cgan_decoder_block(gr.sync_block):
          def __init__(self, model_path='C:/Users/yasht/Desktop/LPI_CGAN/decoder_lpi.pt'):
              gr.sync_block.__init__(self, name='CGAN_LPI_Decoder', in_sig=[(np.complex64, 512)], out_sig=[(np.complex64, 256)])
              import torch
              self.torch = torch
              self.device = 'cuda' if torch.cuda.is_available() else 'cpu'
              self.model = torch.jit.load(model_path, map_location=self.device)
              self.model.eval()
              self.gpu_input = torch.zeros(1, 2, 512, dtype=torch.float32, device=self.device)
              print(f'[CGAN Dec] Loaded on {self.device}')

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              for i in range(len(in0)):
                  frame = in0[i]
                  # per-frame + PER-CHANNEL normalization: decoder was trained on
                  # zero-mean, unit-power frames; over-the-air gain is arbitrary
                  # and a complex DC offset has DIFFERENT I and Q components, so
                  # each channel's mean must be removed separately
                  v = np.concatenate([frame.real, frame.imag]).astype(np.float32)
                  v[:512] -= v[:512].mean()
                  v[512:] -= v[512:].mean()
                  v = v / np.sqrt((v * v).mean() + 1e-8)
                  self.gpu_input[0, 0, :] = self.torch.from_numpy(v[:512])
                  self.gpu_input[0, 1, :] = self.torch.from_numpy(v[512:])
                  with self.torch.no_grad():
                      b_hat = self.model(self.gpu_input).cpu().numpy()[0]
                  symbols = np.where(b_hat > 0.5, 1.0, -1.0).astype(np.complex64)
                  out[i] = symbols
              return len(in0)
    comment: CGAN Decoder (with per-frame normalization)
    model_path: C:/Users/yasht/Desktop/LPI_CGAN/decoder_lpi.pt
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '256'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Inline-decoded symbols (pre-alignment - use rx_raw.fc32 + ota_verify.py for the real BER)
    file: C:\\Users\\yasht\\Desktop\\LPI_CGAN\\recovered_symbols.fc32
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: RX I
    label2: RX Q
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [uhd_usrp_source_0, '0', blocks_file_sink_raw, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_stream_to_vector_0, '0', epy_block_0, '0']
- [epy_block_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
