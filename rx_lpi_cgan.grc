options:
  parameters:
    author: yasht
    description: CGAN RX lab scaffold; requires external frame/carrier synchronization
    generate_options: qt_gui
    id: rx_lpi_cgan
    output_language: python
    title: LPI-CGAN Receiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: 'UNSET: enter an authorized frequency supported by your exact USRP before running'
    value: '0'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: frame_size
  id: variable
  parameters:
    value: '512'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    clock_rate: 30.72e6
    gain0: rx_gain
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: blocks_file_sink_raw
  id: blocks_file_sink
  parameters:
    comment: Raw capture for offline inspection; no synchronization or validated OTA assessment
    file: rx_raw.fc32
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    comment: Accumulate 512 covert samples into one vector
    num_items: '512'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source: |
      import numpy as np
      from gnuradio import gr

      class cgan_decoder_block(gr.sync_block):
          def __init__(self, model_path='decoder_lpi.pt', remove_dc=False, normalize_rms=False):
              gr.sync_block.__init__(self, name='CGAN_LPI_Decoder', in_sig=[(np.complex64, 512)], out_sig=[(np.complex64, 256)])
              import torch
              self.torch = torch
              self.device = 'cuda' if torch.cuda.is_available() else 'cpu'
              self.model = torch.jit.load(model_path, map_location=self.device).eval()
              self.remove_dc = bool(remove_dc)
              self.normalize_rms = bool(normalize_rms)
              print(f'[CGAN Dec] Loaded on {self.device}; remove_dc={self.remove_dc}; normalize_rms={self.normalize_rms}')

          def work(self, input_items, output_items):
              frames = input_items[0]
              out = output_items[0]
              if len(frames) == 0:
                  return 0
              iq = np.stack((frames.real, frames.imag), axis=1).astype(np.float32, copy=False)
              if self.remove_dc:
                  iq = iq - iq.mean(axis=2, keepdims=True)
              if self.normalize_rms:
                  rms = np.sqrt(np.mean(iq * iq, axis=(1, 2), keepdims=True) + 1e-8)
                  iq = iq / rms
              tensor = self.torch.from_numpy(np.ascontiguousarray(iq)).to(self.device)
              with self.torch.inference_mode():
                  probabilities = self.model(tensor).cpu().numpy()
              out[:] = np.where(probabilities > 0.5, 1.0, -1.0).astype(np.complex64)
              return len(frames)
    comment: Decoder only; no preamble/frame/CFO/phase synchronization is implemented
    model_path: decoder_lpi.pt
    remove_dc: 'False'
    normalize_rms: 'False'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '256'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Decoder output; graph assumes exact 512-sample frame alignment
    file: recovered_symbols.fc32
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: RX I
    label2: RX Q
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [uhd_usrp_source_0, '0', blocks_file_sink_raw, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_stream_to_vector_0, '0', epy_block_0, '0']
- [epy_block_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
